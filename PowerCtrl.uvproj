# Keil uVision project PowerCtrl.uvproj, settings and files
target MainCtrl (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: PowerCtrl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App;.\Drive;.\Service
  group App
    ./App/: main.c version.h led.c
  group Service
    ./Service/: delay.c comm1.c mem.c comm2.c dac7311.c modbusCRC.c measure.c debug.c adjust.c
    ./App/: modbus.c mastercomm.c mastercomm.h modbus.h
  group Drive
    ./Drive/: drive.c timer0.c uart3.c io.c adc.c uart1.c watchdog.c eeprom.c
